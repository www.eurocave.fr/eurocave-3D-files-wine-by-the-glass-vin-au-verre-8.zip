Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-01-26T09:43:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 26 09:43:31 2018 * Host: LT-SMN * Database: C:\Users\SEBAST~1\AppData\Local\Temp\{ECD56DE5-DDD6-49CE-B9EA-09956E143027}\ifc * Database version: 5507 * Database creation date: Fri Jan 26 09:43:30 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 26 09:43:31 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 26 09:43:31 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification - Nom du type: Ligne du Niveau; Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Contraintes - Base de l'élévation: Point de base du projet; Elévation: 0 m
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau; Nom de la famille: Niveau
Cotes - Hauteur de calcul: 0 m

# IfcBuildingElementProxy: V08 V0V4 - E (FR), V08 VOV4 - E (FR):V08 V0V4 - E (FR):238410
In: Niveau 0
Material: EUROCAVE - Plastique noir, EUROCAVE - Acier poli, EUROCAVE - Plastique semi transparent, EUROCAVE - Intérieur, EUROCAVE - prise gaz, EUROCAVE - prise électrique, EUROCAVE - Vitre, EUROCAVE - Porte verre
Pset_BuildingElementProxyCommon - Reference: V08 V0V4 - E (FR)
Pset_ManufacturerTypeInformation - Manufacturer: EuroCave
Autre - Catégorie: Equipement spécialisé; Famille: V08 VOV4 - E (FR): V08 V0V4 - E (FR); Famille et type: V08 VOV4 - E (FR): V08 V0V4 - E (FR); ID du type: V08 VOV4 - E (FR): V08 V0V4 - E (FR); Type: V08 VOV4 - E (FR): V08 V0V4 - E (FR); Autres certificats produits: Origine France Garantie -UL, CE, CB, PSE; Certificat hygiène: NSF - Règlement (CE) n°1935/2004 et n° 2023/2006; Marquage CE: yes; Marquage ETL: yes; Nom de la famille: V08 VOV4 - E (FR)
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Nb norme: 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 2.76335 m2; Volume: 0.272726 m3
Electricité - 100V / 50-60 Hz: no; 110V-120V / 60 Hz: no; 220V / 60 Hz: no; 220V-240V / 50 Hz: no; Fréquence: 0 Hz; Intensité nominale: 0 A; Phase: 1; Puissance électrique: 0 W; Remarques Electricité: Selectionnez une norme électrique; Tension: 0 V; Type de Raccord Electrique: Prise électrique - Ne pas brancher sur une multiprise; Cordons: CE - 230V 50Hz, CH - 230V 50Hz, UK - 230V 50Hz, USA - 115V 60Hz, Korea - 220V 60Hz, China - 220V 50Hz, Japan - 100V 50/60Hz, Australia - 240V 50Hz
Graphismes - Conditions d'encastrement: yes
Matériaux et finitions - Finition Coffre: Blanc
Phase de construction - Phase de création: Nouvelle construction
Données d'identification - Code de Révision: Jan-18; Commentaires du type: Distributeur de vin au verre; Coût: 0; Description: Vin au Verre 8.0; Durée de Garantie: 2 à 4 ans selon contrat; Fabricant: EuroCave; Modèle: VV8.0; Nom du type: V08 V0V4 - E (FR); URL: https://www.eurocavepro.fr/; URL catalogue: http://com.eurocave.fr/EuroCave-professional-catalogue/Catalogue-EuroCave-Professional-Francais.pdf
Général - Hauteur hors tout: 0.735 m; Longueur hors tout: 1.035 m; Poids net à vide: 85; Profondeur hors tout: 0.585 m; Spécification du Fabricant: Respecter les conditions d'encastrement - Prévoir branchement bouteille azote; Zone d'installation: Sur un bar ou encastrable sous conditions
Génie climatique - Classe Climatique: SN; Indice de Rendement Energétique: -; Type Fluide Frigorigène: R134
Propriétés du modèle - Capacité (Nombre max de bouteilles): 16; Niveau Sonore: -; Nombre de températures: 2; Plage de réglage des températures: 6-18°C; Températures limites d'utilisation: 10-35°C
